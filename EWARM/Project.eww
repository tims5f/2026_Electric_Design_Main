<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2026_Electric_Design_Main.ewp</path>
  </project>
  <batchBuild />
</workspace>
